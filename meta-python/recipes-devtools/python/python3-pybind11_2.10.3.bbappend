SRC_URI = "git://github.com/pybind/pybind11.git;branch=smart_holder;protocol=https"
 
SRCREV = "c6e71cf71cf11b5b2f58791998b1a0207759d3df"
